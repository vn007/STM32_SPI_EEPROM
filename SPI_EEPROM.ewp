# IAR project SPI_EEPROM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: C:\DATA\ARM\ST\Libraries\STM32F10x_StdPeriph_Driver\inc; C:\DATA\ARM\ST\Libraries\STM32F10x_StdPeriph_Driver\src; C:\DATA\ARM\ST\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; C:\DATA\ARM\ST\Libraries\CMSIS\CM3\CoreSupport; C:\Program Files\IAR Systems\Embedded Workbench 8.0\arm\CMSIS\Core\Include; C:\DATA\ARM\ST\prj\test\SPI_EEPROM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_EEPROM.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\DATA\ARM\ST\prj\test\SPI_EEPROM\stm32f103xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: eeprom.c main.c spi.c startup_stm32f10x_md.s system_stm32f10x.c utils.c
  group SPL
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
